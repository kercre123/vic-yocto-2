RDEPENDS:${PN} += "\
                nativesdk-avbtool-sdk \
                "
