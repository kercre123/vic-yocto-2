FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://alsa-utils-strlcpy-fix.patch"
